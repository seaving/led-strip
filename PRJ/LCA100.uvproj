# Keil uVision project LCA100.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: LCA100 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\APP\FRAME;..\COM;..\DRV;..\HAL;..\APP
  group APP-FRAME
    ../APP/FRAME/: action.c breath.c cache.c color_ctrl.c colors.c hsv.c player.c position_ctrl.c timer.c fft.c mic.c
  group APP
    ../APP/: init.c ir.c main.c action_com.c fountain.c line.c interval.c random.c tetris.c line_music.c fountain_music.c stretch_music.c interval_music.c random_music.c
  group HAL
    ../HAL/: hal_led.c
  group DRV
    ../DRV/: drv_adc.c drv_delay.c drv_eeprom.c drv_uart.c drv_uc1903_hs.c drv_ir.c
